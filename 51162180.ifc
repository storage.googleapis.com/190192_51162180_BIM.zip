Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-14T08:34:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 14 08:34:57 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{F458FF14-CFBD-4BBF-B8B5-F10EC33EF976}\ifc * Database version: 5507 * Database creation date: Thu Jun 14 08:34:56 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 14 08:34:57 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 14 08:34:57 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 51162180 Spout, 51162180:51162180 Spout:338962
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - NominalDepth: 212 mm; NominalHeight: 75 mm; NominalWidth: 75 mm; Projection: 195 mm
Type - General - Author: Convergo AB; BIMObjectName: 51162180; ConvergoRefNr: 0087-1806-0074-FI; ExpiringDate: 12/2018; ManufacterURL: http://hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_08; Uniclass2015Description: Bath spouts; Uniclass2015Reference: Pr_40_20_87_08; Version: 1; VersionDate: 12/06/2018
Type - Green Building Properties - EAN Number: 4057304006975
Type - Identity Data - Group: Spouts; Manufacturer: Hansa; Market: DEU;INT; Model: 51162180 Spout; Name_en: 51162180 Spout; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 51162180; Product Datasheet: http://dbint.hansa.com/index.php?IdProduct=128632&IdTreeGroup=837; Product Family: HANSADESIGNO; Type Name: 51162180 Spout
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation Type: Wall mounted; Max. Hot Water Supply: 90 kg/K/s3
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 51162180; Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 51162180; Name: 51162180 Spout; ReplacementCost: n/a; Shape: Sculptured; Size: 75x212x109 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text - Technology Sales Arguments: Hansa Marix
Pset_ManufacturerTypeInformation - ModelReference: 51162180; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 51162180 Spout
Constraints - DefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.040488 m2; ConnectorDirection: 1; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 30 mm; OutletAngle: 90 deg; Volume: 0.00122784 m3
Identity Data - Mark: 23
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 51162180: 51162180 Spout; Family and Type: 51162180: 51162180 Spout; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 51162180: 51162180 Spout; Type Id: 51162180: 51162180 Spout; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
